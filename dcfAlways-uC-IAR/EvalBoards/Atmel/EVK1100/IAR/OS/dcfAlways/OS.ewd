<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>FLASH</name>
    <toolchain>
      <name>AVR32</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>C-SPY</name>
      <archiveVersion>4</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>CMandatory</name>
          <state>1</state>
        </option>
        <option>
          <name>CInput</name>
          <state>1</state>
        </option>
        <option>
          <name>CCore</name>
          <state>0</state>
        </option>
        <option>
          <name>CRunToEnable</name>
          <state>1</state>
        </option>
        <option>
          <name>CRunToName</name>
          <state>main</state>
        </option>
        <option>
          <name>CMacOverride</name>
          <state>0</state>
        </option>
        <option>
          <name>CMacFile</name>
          <state></state>
        </option>
        <option>
          <name>DynDriver</name>
          <state>JTAGICEMKIIAVR32</state>
        </option>
        <option>
          <name>DDFOverride</name>
          <state>0</state>
        </option>
        <option>
          <name>DDFFile</name>
          <state>$TOOLKIT_DIR$\config\iouc3a0512.ddf</state>
        </option>
        <option>
          <name>DebuggerUseUbrofResetVector</name>
          <state>0</state>
        </option>
        <option>
          <name>IExtraOptionsCheck</name>
          <state>0</state>
        </option>
        <option>
          <name>IExtraOptions</name>
          <state></state>
        </option>
        <option>
          <name>OCImagesSuppressCheck1</name>
          <state>0</state>
        </option>
        <option>
          <name>OCImagesPath1</name>
          <state></state>
        </option>
        <option>
          <name>OCImagesSuppressCheck2</name>
          <state>0</state>
        </option>
        <option>
          <name>OCImagesPath2</name>
          <state></state>
        </option>
        <option>
          <name>OCImagesSuppressCheck3</name>
          <state>0</state>
        </option>
        <option>
          <name>OCImagesPath3</name>
          <state></state>
        </option>
        <option>
          <name>OCImagesOffset1</name>
          <state></state>
        </option>
        <option>
          <name>OCImagesOffset2</name>
          <state></state>
        </option>
        <option>
          <name>OCImagesOffset3</name>
          <state></state>
        </option>
        <option>
          <name>OCImagesUse1</name>
          <state>0</state>
        </option>
        <option>
          <name>OCImagesUse2</name>
          <state>0</state>
        </option>
        <option>
          <name>OCImagesUse3</name>
          <state>0</state>
        </option>
      </data>
    </settings>
    <settings>
      <name>AVRONE</name>
      <archiveVersion>6</archiveVersion>
      <data>
        <version>4</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>CAvrOneMandatory</name>
          <state>1</state>
        </option>
        <option>
          <name>CAvrOnePeripherals</name>
          <state>0</state>
        </option>
        <option>
          <name>CAvrOneSWBreakpoints</name>
          <state>0</state>
        </option>
        <option>
          <name>CAvrOneSuppressDownload</name>
          <state>0</state>
        </option>
        <option>
          <name>CAvrOneVerifyDownload</name>
          <state>0</state>
        </option>
        <option>
          <name>CAvrOneCommunicationLogging</name>
          <state>0</state>
        </option>
        <option>
          <name>CAvrOneCommLogFile</name>
          <state></state>
        </option>
        <option>
          <name>CAvrOneDaisyChainBeforeDevices</name>
          <state>0</state>
        </option>
        <option>
          <name>CAvrOneDaisyChainBeforeBits</name>
          <state>0</state>
        </option>
        <option>
          <name>CAvrOneDaisyChainAfterDevices</name>
          <state>0</state>
        </option>
        <option>
          <name>CAvrOneDaisyChainAfterBits</name>
          <state>0</state>
        </option>
        <option>
          <name>FlashLoaders</name>
          <state></state>
        </option>
        <option>
          <name>UseFlashLoader</name>
          <state>0</state>
        </option>
        <option>
          <name>CAvrOneJtagChainConfig</name>
          <state>0</state>
        </option>
        <option>
          <name>CAvrOneEnableFlashVault</name>
          <state>0</state>
        </option>
        <option>
          <name>CAvrOneDisableSecuredDebugging</name>
          <state>0</state>
        </option>
        <option>
          <name>CAvrOneFlashVaultSlave</name>
          <state>0</state>
        </option>
        <option>
          <name>CAvrOneAwireFrequency</name>
          <state></state>
        </option>
        <option>
          <name>CAvrOneJtagFrequency</name>
          <state>32000</state>
        </option>
        <option>
          <name>CJtagIce3ConnectionUsbId</name>
          <state></state>
        </option>
      </data>
    </settings>
    <settings>
      <name>JTAGICE3</name>
      <archiveVersion>1</archiveVersion>
      <data>
        <version>0</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>CJtagIce3Mandatory</name>
          <state>1</state>
        </option>
        <option>
          <name>CJtagIce3Peripherals</name>
          <state>0</state>
        </option>
        <option>
          <name>CJtagIce3SWBreakpoints</name>
          <state>0</state>
        </option>
        <option>
          <name>CJtagIce3SuppressDownload</name>
          <state>0</state>
        </option>
        <option>
          <name>CJtagIce3VerifyDownload</name>
          <state>0</state>
        </option>
        <option>
          <name>CJtagIce3CommunicationLogging</name>
          <state>0</state>
        </option>
        <option>
          <name>CJtagIce3CommLogFile</name>
          <state></state>
        </option>
        <option>
          <name>CJtagIce3JtagFrequence</name>
          <state>1000</state>
        </option>
        <option>
          <name>CJtagIce3DaisyChainBeforeDevices</name>
          <state>0</state>
        </option>
        <option>
          <name>CJtagIce3DaisyChainBeforeBits</name>
          <state>0</state>
        </option>
        <option>
          <name>CJtagIce3DaisyChainAfterDevices</name>
          <state>0</state>
        </option>
        <option>
          <name>CJtagIce3DaisyChainAfterBits</name>
          <state>0</state>
        </option>
        <option>
          <name>FlashLoaders</name>
          <state></state>
        </option>
        <option>
          <name>UseFlashLoader</name>
          <state>0</state>
        </option>
        <option>
          <name>CJtagIce3JtagChainConfig</name>
          <state>0</state>
        </option>
        <option>
          <name>CJtagIce3EnableFlashVault</name>
          <state>0</state>
        </option>
        <option>
          <name>CJtagIce3DisableSecuredDebugging</name>
          <state>0</state>
        </option>
        <option>
          <name>CJtagIce3FlashVaultSlave</name>
          <state>0</state>
        </option>
        <option>
          <name>CJtagIce3AwireFrequency</name>
          <state></state>
        </option>
        <option>
          <name>CJtagIce3ConnectionUsbId</name>
          <state></state>
        </option>
      </data>
    </settings>
    <settings>
      <name>JTAGICEMKIIAVR32</name>
      <archiveVersion>5</archiveVersion>
      <data>
        <version>4</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>CJtagIceMkIIMandatory</name>
          <state>1</state>
        </option>
        <option>
          <name>CJtagIceMkIIPeripherals</name>
          <state>0</state>
        </option>
        <option>
          <name>CJtagIceMkIISWBreakpoints</name>
          <state>1</state>
        </option>
        <option>
          <name>CJtagIceMkIISuppressDownload</name>
          <state>0</state>
        </option>
        <option>
          <name>CJtagIceMkIIVerifyDownload</name>
          <state>0</state>
        </option>
        <option>
          <name>CJTagIceMkIICommunicationLogging</name>
          <state>0</state>
        </option>
        <option>
          <name>CJtagIceMkIICommLogFile</name>
          <state></state>
        </option>
        <option>
          <name>CJtagIceMkIIConnectionRage</name>
          <version>0</version>
          <state>2</state>
        </option>
        <option>
          <name>CJtagIceMkIIConnectionPort</name>
          <version>0</version>
          <state>0</state>
        </option>
        <option>
          <name>CJtagIceMkIIDaisyChain</name>
          <state>0</state>
        </option>
        <option>
          <name>CJtagIceMkIIDaisyChainBeforeDevices</name>
          <state>0</state>
        </option>
        <option>
          <name>CJtagIceMkIIDaisyChainBeforeBits</name>
          <state>0</state>
        </option>
        <option>
          <name>CJtagIceMkIIDaisyChainAfterDevices</name>
          <state>0</state>
        </option>
        <option>
          <name>CJtagIceMkIIDaisyChainAfterBits</name>
          <state>0</state>
        </option>
        <option>
          <name>FlashLoaders</name>
          <state></state>
        </option>
        <option>
          <name>UseFlashLoader</name>
          <state>0</state>
        </option>
        <option>
          <name>CJtagIceMkIIEnableFlashVault</name>
          <state>0</state>
        </option>
        <option>
          <name>CJtagIceMkIIDisableSecuredDebugging</name>
          <state>0</state>
        </option>
        <option>
          <name>CJtagIceMkIIFlashVaultSlave</name>
          <state>0</state>
        </option>
        <option>
          <name>CAvrOneAwireFrequency</name>
          <state></state>
        </option>
        <option>
          <name>CJtagIceMkIIConnectionUsbId</name>
          <state></state>
        </option>
      </data>
    </settings>
    <settings>
      <name>SIMAVR32</name>
      <archiveVersion>2</archiveVersion>
      <data>
        <version>0</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>CSimMandatory</name>
          <state>1</state>
        </option>
      </data>
    </settings>
    <debuggerPlugins>
      <plugin>
        <file>$TOOLKIT_DIR$\plugins\rtos\embOS\embOSPlugin.ewplugin</file>
        <loadFlag>0</loadFlag>
      </plugin>
      <plugin>
        <file>$TOOLKIT_DIR$\plugins\rtos\ThreadX\ThreadXAvr32Plugin.ewplugin</file>
        <loadFlag>0</loadFlag>
      </plugin>
      <plugin>
        <file>$TOOLKIT_DIR$\plugins\rtos\uCOS-II\uCOS-II-286-KA-CSpy.ewplugin</file>
        <loadFlag>0</loadFlag>
      </plugin>
      <plugin>
        <file>$TOOLKIT_DIR$\plugins\rtos\uCOS-II\uCOS-II-KA-CSpy.ewplugin</file>
        <loadFlag>1</loadFlag>
      </plugin>
      <plugin>
        <file>$TOOLKIT_DIR$\plugins\Stk600\Stk600Plugin.ewplugin</file>
        <loadFlag>0</loadFlag>
      </plugin>
      <plugin>
        <file>$EW_DIR$\common\plugins\CodeCoverage\CodeCoverage.ENU.ewplugin</file>
        <loadFlag>0</loadFlag>
      </plugin>
      <plugin>
        <file>$EW_DIR$\common\plugins\Orti\Orti.ENU.ewplugin</file>
        <loadFlag>0</loadFlag>
      </plugin>
      <plugin>
        <file>$EW_DIR$\common\plugins\SymList\SymList.ENU.ewplugin</file>
        <loadFlag>1</loadFlag>
      </plugin>
    </debuggerPlugins>
  </configuration>
</project>


