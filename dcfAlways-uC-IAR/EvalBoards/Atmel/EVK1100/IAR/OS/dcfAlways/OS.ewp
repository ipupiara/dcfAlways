# IAR project OS.ewp, settings and files
configuration FLASH (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32allasf.h
  General.GSStackSize: 0x400
  General.GCStackSize: 0x400
  General.GHeapSize: 0x100
  ICCAVR32.CCIncludePath2: $PROJ_DIR$; ..\..\BSP; ..\..\asf; ..\..\..\..\..\..\uCOS-II\Ports\AVR32\UC3\IAR; ..\..\..\..\..\..\uCOS-II\Source; ..\..\..\..\..\..\uC-CPU\AVR32\UC3\IAR; ..\..\..\..\..\..\uC-CPU; ..\..\asf\sdramc; ..\..\asf\usb\drivers\usbb; ..\..\asf\usb\drivers\usbc; ..\..\asf\usb; ..\..\asf\usb\class\hid; ..\..\asf\usb\class\hid\device; ..\..\asf\usb\class\hid\device\generic; ..\..\asf\usb\class\hid\device\generic\module_config; ..\..\asf\usb\udc; ..\..\..\..\..\..\uC-TCPIP\Source; ..\..\..\..\..\..\uC-TCPIP\OS\uCOS-II; ..\..\..\..\..\..\uC-TCPIP\NIC\Ether\PHY; ..\..\..\..\..\..\uC-TCPIP\NIC\Ether\PHY\DP83848; ..\..\..\..\..\..\uC-TCPIP\NIC\Ether\Atmel_MACB; ..\..\..\..\..\..\uC-TCPIP\IF; ..\..\..\..\..\..\uC-TCPIP\IF\Ether; ..\..\..\..\..\..\uC-TTCP\OS\uCOS-II; ..\..\..\..\..\..\uC-TTCP\Source; ..\..\..\..\..\..\uC-LIB; ..\..\asf\UartPrint
  ICCAVR32.CCOptLevel: 0
  ICCAVR32.CCOptStrategy: 0
  ICCAVR32.IccLang: 0
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ..\..\BSP\lnkuc3a0512.xcl
  group APP
    ./: app.c app_cfg.h includes.h net_cfg.h os_cfg.h ttcp_cfg.h
  group asf
    ../../asf/: board.h compiler.h gpio.c gpio.h interrupt_avr32.h mrepeat.h mt48lc16m16a2tg7e.h pm.c pm.h preprocessor.h rtc.c rtc.h stringz.h tpaste.h
  group asf/EVK1100
    ../../asf/EVK1100/: evk1100.h
  group asf/sdramc
    ../../asf/sdramc/: sdramc.c sdramc.h
  group asf/UartPrint
    ../../asf/UartPrint/: UartPrint.c UartPrint.h
  group asf/usb
    ../../asf/usb/: usb_atmel.h usb_protocol.h
  group asf/usb/class/hid
    ../../asf/usb/class/hid/: usb_protocol_hid.h
  group asf/usb/class/hid/device
    ../../asf/usb/class/hid/device/: udi_hid.c udi_hid.h
  group asf/usb/class/hid/device/generic
    ../../asf/usb/class/hid/device/generic/: udi_hid_generic.c udi_hid_generic.h udi_hid_generic_conf.h udi_hid_generic_desc.c
  group asf/usb/class/hid/device/generic/module_config
    ../../asf/usb/class/hid/device/generic/module_config/: appl_usb.c appl_usb.h conf_usb.h
  group asf/usb/drivers/usbb
    ../../asf/usb/drivers/usbb/: usbb_device.c usbb_device.h usbb_otg.h
  group asf/usb/udc
    ../../asf/usb/udc/: udc.c udc.h udc_desc.h udd.h udi.h
  group BSP
    ../../BSP/: bsp.c bsp.h lnkuc3a0512.xcl net_bsp.c net_bsp.h net_isr.c pdca.c pdca.h rtcPid.c rtcPid.h vectors.asm
  group uC-LIB
    ../../../../../../uC-LIB/: lib_def.h lib_mem.c lib_mem.h lib_str.c lib_str.h
  group uC-TCPIP/NIC
    ../../../../../../uC-TCPIP/NIC/Ether/Atmel_MACB/: net_nic.c net_nic.h net_nic_def.h
  group uC-TCPIP/PHY
    ../../../../../../uC-TCPIP/NIC/Ether/PHY/DP83848/: net_phy.c net_phy.h
    ../../../../../../uC-TCPIP/NIC/Ether/PHY/: net_phy_def.h
  group uC-TCPIP/Source
    ../../../../../../uC-TCPIP/Source/: net.c net.h net_arp.c net_arp.h net_ascii.c net_ascii.h net_bsd.c net_bsd.h net_buf.c net_buf.h net_cfg_net.h net_conn.c net_conn.h net_ctr.c net_ctr.h net_dbg.c net_dbg.h net_def.h net_err.c net_err.h net_icmp.c net_icmp.h net_ip.c net_ip.h net_sock.c net_sock.h net_stat.c net_stat.h net_tcp.c net_tcp.h net_tmr.c net_tmr.h net_type.h net_udp.c net_udp.h net_util.c net_util.h
  group uC-TCPIP/Source/NetIF
    ../../../../../../uC-TCPIP/IF/Ether/: net_if.c net_if.h
    ../../../../../../uC-TCPIP/IF/: net_if_pkt.c net_if_pkt.h
  group uC-TCPIP/Source/OS Port
    ../../../../../../uC-TCPIP/OS/uCOS-II/: net_os.c net_os.h
  group uC/CPU
    ../../../../../../uC-CPU/AVR32/UC3/IAR/: cpu.h cpu_a.asm
    ../../../../../../uC-CPU/: cpu_def.h
  group uC/OS-II/Source
    ../../../../../../uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c ucos_ii.h
  group uC/OS-II/uC/OS-II Port
    ../../../../../../uCOS-II/Ports/AVR32/UC3/IAR/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c
